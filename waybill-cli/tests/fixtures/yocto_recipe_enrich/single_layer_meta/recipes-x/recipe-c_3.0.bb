LICENSE = "CLOSED"
SUMMARY = "Proprietary recipe C"
