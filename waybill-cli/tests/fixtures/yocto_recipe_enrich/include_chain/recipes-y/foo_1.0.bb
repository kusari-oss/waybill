require foo.inc
LICENSE = "MIT"
