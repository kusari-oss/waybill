LICENSE = "MIT"
SUMMARY = "Widget library from github"
SRC_URI = "git://github.com/example/widget.git;branch=main;protocol=https"
SRCREV = "abc123def456abc123def456abc123def456abcd"
