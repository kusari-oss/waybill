LICENSE = "Apache-2.0"
SUMMARY = "Gadget with literal git PV"
SRCREV = "1234567890abcdef0123456789abcdef01234567"
