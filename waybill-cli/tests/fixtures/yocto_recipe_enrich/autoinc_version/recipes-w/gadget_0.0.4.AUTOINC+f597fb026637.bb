LICENSE = "MIT"
SUMMARY = "Gadget with AUTOINC version"
SRCREV = "f597fb026637abcdef0123456789abcdef0123ab"
