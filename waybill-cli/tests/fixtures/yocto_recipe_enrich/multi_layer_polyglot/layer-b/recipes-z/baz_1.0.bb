LICENSE = "MIT"
SUMMARY = "Baz recipe in layer-b"
