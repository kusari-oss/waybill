SRC_URI:append = " file://patch-from-layer-b.patch"
