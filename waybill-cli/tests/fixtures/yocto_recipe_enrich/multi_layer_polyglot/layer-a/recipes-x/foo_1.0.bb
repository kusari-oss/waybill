LICENSE = "MIT"
SUMMARY = "Foo recipe in layer-a"
DEPENDS = "bar openssl-dev"
