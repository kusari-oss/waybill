LICENSE = "Apache-2.0"
SUMMARY = "Bar recipe in layer-a, depended on by foo"
