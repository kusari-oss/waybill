# Synthetic recipe with git-version suffix. waybill preserves the
# suffix verbatim in the emitted PURL version segment.
SUMMARY = "Fixture app for waybill milestone 107 recipe-walker test"
LICENSE = "Apache-2.0"
