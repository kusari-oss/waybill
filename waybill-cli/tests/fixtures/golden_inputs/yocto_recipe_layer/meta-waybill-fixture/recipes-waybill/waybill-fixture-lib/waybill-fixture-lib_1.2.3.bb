# Synthetic BitBake recipe — waybill only reads the filename.
SUMMARY = "Fixture lib for waybill milestone 107 recipe-walker test"
LICENSE = "MIT"
