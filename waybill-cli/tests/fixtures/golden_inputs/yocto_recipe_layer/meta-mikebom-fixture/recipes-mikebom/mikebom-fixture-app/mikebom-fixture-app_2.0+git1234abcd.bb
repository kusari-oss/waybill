# Synthetic recipe with git-version suffix. mikebom preserves the
# suffix verbatim in the emitted PURL version segment.
SUMMARY = "Fixture app for mikebom milestone 107 recipe-walker test"
LICENSE = "Apache-2.0"
