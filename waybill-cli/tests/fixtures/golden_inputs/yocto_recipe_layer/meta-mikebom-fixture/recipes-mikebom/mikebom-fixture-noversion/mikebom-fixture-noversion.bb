# Synthetic recipe without an _<version> segment. mikebom emits
# the component with version "unknown" + mikebom:version-status
# annotation rather than dropping it (per FR-007 + the data-model
# spec).
SUMMARY = "Fixture recipe with no version in filename"
LICENSE = "BSD-3-Clause"
