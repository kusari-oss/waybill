# Synthetic BitBake recipe — mikebom only reads the filename.
SUMMARY = "Fixture lib for mikebom milestone 107 recipe-walker test"
LICENSE = "MIT"
