# Synthetic recipe with unexpanded BitBake variables in the
# filename — waybill skips this silently per FR-008.
SUMMARY = "Shared-base recipe; waybill skips this"
LICENSE = "Closed"
